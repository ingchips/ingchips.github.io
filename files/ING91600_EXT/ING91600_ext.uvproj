# Keil uVision project ING91600_ext.uvproj, settings and files
target Cortex-M (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: ING91600_EXT
  AfterMake: cmd.exe /C copy "output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: C:\Keil\ARM\Flash;.\sdk\StartUP\ing916;.\sdk\FWlib;.\sdk\BSP
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group sdk
    ./sdk/FWlib/: peripheral_ssp.c peripheral_sysctrl.c
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
